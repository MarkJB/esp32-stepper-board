# Repository MarkJB/esp32-stepper-board

## KiCad design esp32_stepper_board.kicad_pcb

Parts:
C1: 10u; CP_Radial_D8.0mm_P2.50mm
C2: 100u; CP_Radial_D8.0mm_P2.50mm
C3, C4, C5: 100u; C_Radial_lying_flat_D8_L11_P2.5
C6: 100n; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: AUX_2A_GPIO_LN; JST_PH_B6B-PH-K_06x2.00mm_Straight
J2: DC_PWR; BARREL_JACK
J3: Servo; JST_PH_B3B-PH-K_03x2.00mm_Straight
J4: Stepper A/X; JST_PH_B4B-PH-K_04x2.00mm_Straight
J5: Stepper B/Y; JST_PH_B4B-PH-K_04x2.00mm_Straight
J6: Stepper C/Z; JST_PH_B4B-PH-K_04x2.00mm_Straight
J7: Endstop A/X; JST_PH_B3B-PH-K_03x2.00mm_Straight
J8: Endstop B/Y; JST_PH_B3B-PH-K_03x2.00mm_Straight
J9: Endstop C/Z; JST_PH_B3B-PH-K_03x2.00mm_Straight
J10: Aux1_I2C; JST_PH_B4B-PH-K_04x2.00mm_Straight
J11: IO0_IO2_JP; Pin_Header_Straight_1x02_Pitch2.54mm
J12: PWRSEL_2A; Pin_Header_Straight_1x03_Pitch2.54mm
J13: AUX_2B_GPIO_HN; JST_PH_B6B-PH-K_06x2.00mm_Straight
J14: PWRSEL_2B; Pin_Header_Straight_1x03_Pitch2.54mm
R1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R2, R3: 4.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
SW1: SW_DIP_x01; SlideSw
U1: LM1117-5.0; TO-220-3_Vertical
U2, U5, U6: STEPSTICK; Stepstick
U3: lc_tech_sd_module
U4: ESP-DEVKITC; DEVKITC
U7: rotary_enc_module; ky-040-rotary-encoder-module
U8: OLED_I2C; ssd1306_oled_0.96in
U9: PCF8574; DIP-16_W7.62mm

Connections:
/3v3: C6.1, J7.3, J8.3, J9.3, J10.3, J12.3, J14.3, R1.1, R2.1, R3.1, U2.13 (~RESET), U2.14 (~SLEEP), U3.1 (3v3), U4.1 (3V3), U5.13 (~RESET), U5.14 (~SLEEP), U6.13 (~RESET), U6.14 (~SLEEP), U7.4 (Vin), U8.2 (VDD), U9.16 (VDD)
/5v: C2.1, J3.2, J12.1, J14.1, U1.2 (VO), U4.19 (5V)
/12v: C1.1, C3.1, C4.1, C5.1, SW1.2, U1.3 (VI), U2.8 (Vstepper), U5.8 (Vstepper), U6.8 (Vstepper)
/A/X_A1: J4.3, U2.4 (A1)
/A/X_A2: J4.4, U2.3 (A2)
/A/X_B1: J4.2, U2.5 (B1)
/A/X_B2: J4.1, U2.6 (B2)
/A/X_DIR: U2.16 (DIR), U4.28 (IO17)
/A/X_STEP: U2.15 (STEP), U4.27 (IO16)
/B/Y_A1: J5.3, U5.4 (A1)
/B/Y_A2: J5.4, U5.3 (A2)
/B/Y_B1: J5.2, U5.5 (B1)
/B/Y_B2: J5.1, U5.6 (B2)
/B/Y_DIR: U4.30 (IO18), U5.16 (DIR)
/B/Y_STEP: U4.29 (IO5), U5.15 (STEP)
/C/Z_A1: J6.3, U6.4 (A1)
/C/Z_A2: J6.4, U6.3 (A2)
/C/Z_B1: J6.2, U6.5 (B1)
/C/Z_B2: J6.1, U6.6 (B2)
/C/Z_DIR: U4.33 (IO21), U6.16 (DIR)
/C/Z_STEP: U4.31 (IO19), U6.15 (STEP)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.5, J2.2, J3.3, J7.2, J8.2, J9.2, J10.1, J13.5, U1.1 (GND), U2.1 (GND), U2.7 (GND), U3.6 (GND), U4.14 (GND2), U4.32 (GND), U4.38 (GND3), U5.1 (GND), U5.7 (GND), U6.1 (GND), U6.7 (GND), U7.5 (GND), U8.1 (GND), U9.1 (A0), U9.2 (A1), U9.3 (A2), U9.8 (VSS)
/GPIO_EX0: J1.4, U9.4 (P0)
/GPIO_EX1: J1.3, U9.5 (P1)
/GPIO_EX2: J1.2, U9.6 (P2)
/GPIO_EX3: J1.1, U9.7 (P3)
/GPIO_EX4: J13.4, U9.9 (P4)
/GPIO_EX5: J13.3, U9.10 (P5)
/GPIO_EX6: J13.2, U9.11 (P6)
/GPIO_EX7: J13.1, U9.12 (P7)
/IO0: J11.2, U4.25 (IO0)
/PWR1: J1.6, J12.2
/PWR2: J13.6, J14.2
/RENC_CLK: U4.15 (IO13), U7.1 (CLK)
/RENC_DT: U4.13 (IO12), U7.2 (DT)
/RX: U4.34 (RXD0)
/SCL1: J10.4, R3.2, U4.8 (IO33), U8.3 (SCL), U9.15 (SDA)
/SDA1: J10.2, R2.2, U4.7 (IO32), U8.4 (SDA), U9.14 (SCL)
/SD_MISO: U3.5 (MISO), U4.23 (IO15)
/SD_MOSI: J11.1, U3.3 (MOSI), U4.24 (IO2)
/SD_SCK: U3.4 (CLK), U4.12 (IO14)
/SERVO: J3.1, U4.36 (IO22)
/STEP_M0: U2.10 (M0), U4.9 (IO25), U5.10 (M0), U6.10 (M0)
/STEP_M1: U2.11 (M1), U4.10 (IO26), U5.11 (M1), U6.11 (M1)
/STEP_M2: U2.12 (M2), U4.11 (IO27), U5.12 (M2), U6.12 (M2)
/TX: U4.35 (TXDO)
/Vin: J2.1, SW1.1
/~ES_A/X: J7.1, U4.3 (IO36/SVP)
/~ES_B/Y: J8.1, U4.4 (IO39/VN)
/~ES_C/Z: J9.1, U4.5 (IO34)
/~PCFA_INT: U4.6 (IO35), U9.13 (~INT~)
/~RENC_SW: U4.37 (IO23), U7.3 (SW)
/~STEP_EN: U2.9 (~ENABLE), U4.26 (IO4), U5.9 (~ENABLE), U6.9 (~ENABLE)
unnamed: R1.2, U3.2 (CS)

Notes on the sheet:
OLED Display and Rotary Encoder
Connectors
ESP-DEVKITC
Stepper Drivers
SD Card
I2C GPIO Expander (PCF8574)
I2C Pull-up
Power

Board: 2 copper layers, 99.9 x 70.2 mm, 33 parts (0 on the bottom side), 52 nets.

## Commit log

2018-03-06 Updated pins, added I2C GPIO expander
2018-03-06 Added PDF of schematic
2018-03-06 Updated schematic & pdf
2018-03-07 Pin optimzation and aux ports
2018-03-07 I2C Pull-ups
2018-03-07 Fix stepper reset & sleep
2018-03-10 Fixed mistake on WROOM symbol & removed pause button
2018-03-10 Updated PDF with changes
2018-03-10 Schematic using Devkitc
2018-03-10 Updated pdf for devkitc
2018-03-10 Added external power and other changes for devkitc
2018-03-12 Test board and components
2018-03-22 fix silk screen label for c/z stepper
2018-03-22 Update pdf with correct label for c/z stepper
2018-03-25 Fixed devkit footprint and rerouted board
2018-03-27 fix flat cap silk and various silk issue
2018-04-08 Fixed devkitc footprint silk, rotated devkitc footprint, fix stepper pwr track width, c_step pin on IO23 (moved from gnd), moved renc_sw from tx.
2018-04-08 Updated schematic and schematic pdf

Notices in the files:
esp32_stepper_board.kicad_pcb:
Licence CC-BY-SA 3.0
